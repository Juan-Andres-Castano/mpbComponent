# IAR project nepDigitalFiltering.ewp, settings and files
configuration nepDigitalFilteringCortexM0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030CC ST STM32F030CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: Includes; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\commun\V100; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\nepMath\V100\Includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: nepDigitalFiltering.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration nepDigitalFilteringCortexM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
configuration nepDigitalFilteringCortexM0+ (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  group Documents
    Documents/: Version.txt
  group Includes
    Includes/: nepDigitalFiltering.h nepDigitalFilteringMovingAverage.h nepDigitalFilteringNms.h nepDigitalFilteringRclp.h
  group Sources
    Sources/: nepDigitalFilteringMovingAverage.c nepDigitalFilteringNms.c nepDigitalFilteringRclp.c
  group Tests
    Tests/: test_nepDigitalFilteringMovingAverage.c test_nepDigitalFilteringNms.c test_nepDigitalFilteringRclp.c
