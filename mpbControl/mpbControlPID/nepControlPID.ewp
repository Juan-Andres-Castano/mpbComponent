# IAR project nepControlPID.ewp, settings and files
configuration nepControlPIDCortexM0 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: Includes; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\commun\V100; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\nepMath\V100\Includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: nepControlPID.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration nepControlPIDCortexM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
configuration nepControlPIDCortexM0+ (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  group Documents
    Documents/: Version.txt
  group Includes
    Includes/: nepControlPID.h nepControlPIDUtil.h
  group Sources
    Sources/: nepControlPID.c nepControlPIDUtil.c
  group Tests
    Tests/: test_nepControlPID.c test_nepControlPIDUtil.c
