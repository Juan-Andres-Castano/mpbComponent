# IAR project Backup of nepControlPID.ewp, settings and files
configuration nepControlPIDCortexM0 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\commun; Includes; ..\..\..\nepMath\Includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: nepControlPID.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration nepControlPIDCortexM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  group Includes
    Includes/: nepControlPID.h nepControlPIDUtil.h
  group Sources
    Sources/: nepControlPID.c nepControlPIDUtil.c
  group Tests
    ../nepControlMotion/Tests/: test_nepControlMotion.c test_nepControlMotionDiscretization.c test_nepControlMotionLoop.c test_nepControlMotionModify.c test_nepControlMotionModifyCase.c test_nepControlMotionModifyUtil.c test_nepControlMotionReference.c test_nepControlMotionReferenceUtil.c test_nepControlMotionSegment.c
    Tests/: test_nepControlPID.c test_nepControlPIDUtil.c
