# IAR project CurrentSensing.ewp, settings and files
configuration CurrentSensingCortexM0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030CC ST STM32F030CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: Includes; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\commun\V100; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\nepMath\V100\Includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CurrentSensing.out
configuration CurrentSensingCortexM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
configuration CurrentSensingCortexM0+ (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  group Documents
    Documents/: Version.txt
  group Includes
    Includes/: CurrentSensing.h
  group Sources
    Sources/: CurrentSensing.c
  group Tests
    Tests/: test_CurrentSensing.c test_CurrentSensing.h
