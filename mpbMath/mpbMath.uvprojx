# Keil uVision project mpbMath.uvprojx, settings and files
target mpbMath (6150000::V6.15::ARMCLANG)
  device: VA416xx Vorago
  pack: Vorago.VA416xx.1.0.3
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpbMath (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\commun\Includes;.\Includes
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Includes
    ./Includes/: mpbMathDebounce.h mpbMath.h mpbMathAverage.h mpbMathCoerce.h mpbMathCrc.h mpbMathCrcUtil.h mpbMathDivision.h mpbMathFifo.h mpbMathLinearApprox.h mpbMathResistor.h mpbMathRound.h
  group Sources
    ./Sources/: mpbMathDebounce.c mpbMathAbsolute.c mpbMathAverage.c mpbMathCoerce.c mpbMathDivision.c mpbMathLinearApprox.c mpbMathResistor.c mpbMathRound.c mpbMathCrc.c mpbMathCrcUtil.c mpbMathFifo.c
