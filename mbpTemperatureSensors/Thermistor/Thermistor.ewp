# IAR project Thermistor.ewp, settings and files
configuration ThermistorCortexM0 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: Includes; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\commun\V100; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\nepMath\V100\Includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Thermistor.out
configuration ThermistorCortexM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  group Documents
    Documents/: Version.txt
  group Includes
    Includes/: NCP18XH103F03RB.h PT103J2.h thermistor.h thermistorCircuit.h thermistorCircuitUtil.h
  group Sources
    Sources/: thermistor.c thermistorCircuit.c thermistorCircuitUtil.c
  group Tests
    Tests/: test_Thermistor.c test_Thermistor.h test_ThermistorCircuit.c test_ThermistorCircuitUtil.c
