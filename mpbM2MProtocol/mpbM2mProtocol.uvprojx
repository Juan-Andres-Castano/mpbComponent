# Keil uVision project mpbM2mProtocol.uvprojx, settings and files
target mpbM2MProtocol (6150000::V6.15::ARMCLANG)
  device: VA416xx Vorago
  pack: Vorago.VA416xx.1.0.3
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpbM2mProtocol (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Includes;..\mpbMath\Includes;..\commun\Includes
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Sources
    ./Sources/: m2mCommandSetup.c mpbBuffer.c mpbCommandConductor.c mpbCommandHandler.c mpbCommandHardware.c mpbPacker.c mpbParser.c mpbSerialDriver.c mpbUtils.c
